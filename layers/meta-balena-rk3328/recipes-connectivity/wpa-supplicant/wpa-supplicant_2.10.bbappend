FILESEXTRAPATHS:append := ":${THISDIR}/files"

SRC_URI:append = " \
    file://0001-wpa-supplicant-disable-linux-macsec-driver.patch \
"
