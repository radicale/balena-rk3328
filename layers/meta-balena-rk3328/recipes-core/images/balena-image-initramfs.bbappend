# This fixes rootfs maxsize override error
IMAGE_ROOTFS_MAXSIZE = "36864"
